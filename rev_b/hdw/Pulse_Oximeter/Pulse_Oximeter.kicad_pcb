# Repository drewsum/pulse_oximeter (continued)

## KiCad design hdw/Pulse_Oximeter/Pulse_Oximeter.kicad_pcb

Board: 4 copper layers, 100.0 x 50.0 mm, 263 parts (67 on the bottom side), 121 nets.

Parts:
C201, C204, C301, C302, C303, C404, C406, C503, C504, C505, C602, C605, C703, C704, C705, C801, C802, C901, C902, C908, C912, C916, C917, C1001, C1201, C1202, C1203, C1205, C1206, C1209, C1301, C1302, C1303, C1404, C1502, C1504, C1508, C1511, C1601, C1603, C1702, C1710, C1801, C1803, C1805, C1806, C1901, C1902, C1903, C1904, C2001: 0.1uF; C_0402
C202, C403, C904, C905, C910, C914, C918, C919, C1003, C1506, C1509, C1512, C1604, C1704: 10nF; C_0402
C203, C906, C907, C911, C915, C920, C921, C1005, C1510, C1513, C1605: 1nF; C_0402
C205: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Reflow
C401: 10uF; C_1206
C402, C601, C603, C604, C903, C909, C913, C1401, C1402, C1403, C1501, C1503, C1505, C1507, C1514, C1602, C1706, C1708, C1802: 10uF; C_0402
C405: 100uF; C_1206
C1204: 4.7uF; C_0402
C1207, C1208: 47pF; C_0402
D201: 24V; D_SMA
D401, D1401: BAT48JFILM; D_SOD-323
D1201: Yellow; LED_0402
D1801, D1802, D1804, D1805, D1901: Green; LED_0402
D1902, D1903, D1904: Red; LED_0402
H2301, H2302, H2303, H2304: MountingHole; MountingHole_3mm
J201: +12V IN; BARREL_JACK
J801: PICKIT3; PICKIT3_Header
J1201: USB_B_Mini; USB_Mini-B
J2001: I2C; PinHeader_1x03_P2.54mm_Vertical
J2002: USB UART; PinHeader_1x03_P2.54mm_Vertical
L401: 3.3uH; L_Vishay_IHLP-1212
L901, L902, L1001, L1201, L1202: 600R 0.5A; L_0402
Q201: Si4946BEY; SOIC-8_3.9x4.9mm_P1.27mm
Q401, Q801: BSS214NW; SOT-323_SC-70
Q402: ZXMS6004FFTA; SOT-23
R201: 6.04M; R_0402
R202: 86.6k; R_0402
R203, R204: 243k; R_0402
R205, R206, R209, R212, R403, R407, R409, R606, R608, R801, R803, R1205, R1209, R2002: 10; R_0402
R207: 13.7k; R_0402
R208, R211: 5.23k; R_0402
R210, R408, R607, R1206: 0.02; R_0612
R213, R405, R406, R601, R602, R802, R804, R1001, R1004, R1006, R1101, R1102, R1204, R1501, R1502, R1503, R1504, R1505, R1506, R1507, R1601, R1602, R1603, R1605, R1606, R1607, R1608, R1609, R1610, R1611, R1612, R1613, R1704, R1706, R1901, R1902, R1905, R1906, R2001: 10k; R_0402
R410: 562k; R_0402
R411: 180k; R_0402
R609: 1.87k; R_0402
R610: 1.5k; R_0402
R805, R1210, R1801, R1802, R1804, R1805, R1903, R1904, R1907, R1908: 1k; R_0402
R1002: 100; R_0402
R1201: 487k; R_0402
R1202: 6.04k; R_0402
R1203: 40.2k; R_0402
R1207, R1208: 27; R_0402
R1604, R1702: 499; R_0402
RV1601: 10k; Potentiometer_Vishay_TS53YL_Vertical
SW801: MRST; SW_PUSH_6mm
SW1702: Cap_Touch; Capacitive_Touch_Pad
TP201: TP; Pin_Header_Angled_1x01_Pitch2.54mm
TP202, TP203, TP401, TP601, TP1001, TP1201: TP; Test_Point
U201: LTC4365DDB; DFN-8-1EP_2x3mm_Pitch0.5mm
U301, U503, U703, U1301: INA219BxDCN; SOT-23-8
U302, U502, U702, U1302, U2001: MCP9804; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm
U401: TPS62150; QFN-16-1EP_3x3mm_P0.5mm_EP1.8x1.8mm
U601: TPS7A91; Texas_S-PDSO-N10_EP1.2x2mm
U1101: PIC32MZ0512EFE064T-I_PT; TQFP-64_10x10mm_P0.5mm
U1201: TLV6700; SOT-23-6
U1202: FT234XD; DFN-12-1EP_3x3mm_Pitch0.45mm
U1203: TPD3S014DBVR; SOT-23-6
U1401: DS1683; SOIC-8_3.9x4.9mm_Pitch1.27mm
U1501: TPS22929D; SOT-23-6
U1502: TCA9803; VSSOP-8_3.0x3.0mm_P0.65mm
U1503: MAX30102; Maxim_OLGA-14_3.3x5.6mm_P0.8mm
U1601, U1706: 74LVC1G17; SOT-353_SC-70-5
U1602: NHD-0420H1Z
U1702, U1801: TPS71530; SOT-353_SC-70-5
U1704: AT42QT1010-TSHR; SOT-23-6
U1802, U1803, U1805, U1806, U1901, U1902, U1903, U1904: 74LVC1G06; SOT-353_SC-70-5
X1001: ASE-8.000MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1.8V: C605.1, C1504.1, C1505.1, C1507.1, C1508.1, C1509.1, C1510.1, R607.2, R608.2, R609.1, R1505.1, R1506.1, TP601.1, U1502.8, U1503.11
+3.3VA_MZ: C917.1, C919.1, C921.1, L901.1, U1101.19
+3.3V_POX: C1511.1, C1512.1, C1513.1, C1514.1, R1503.1, U1501.1, U1503.9, U1503.10
+3V3: C302.1, C303.1, C406.1, C503.1, C505.1, C601.1, C703.1, C705.1, C801.1, C901.1, C902.1, C903.1, C904.1, C905.1, C906.1, C907.1, C908.1, C909.1, C910.1, C911.1, C912.1, C913.1, C914.1, C915.1, C916.1, C918.1, C920.1, C1201.1, C1202.1, C1302.1, C1303.1, C1501.1, C1502.1, C1503.1, C1601.1, C1602.1, C1603.1, C1604.1, C1605.1, C1702.1, C1710.1, C1803.1, C1805.1, C1806.1, C1901.1, C1902.1, C1903.1, C1904.1, C2001.1, D401.2, D1401.2, J801.2, L901.2, L1001.2, Q402.3, R405.1, R408.2, R409.2, R410.1, R601.1, R804.1, R1101.1, R1102.1, R1204.1, R1507.1, R1605.1, R1802.1, R1804.1, R1805.1, R1903.1, R1904.1, R1905.1, R1907.1, R1908.1, R2001.1, RV1601.1, SW801.1, TP401.1, U301.4, U302.8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
+5V_USB: C1203.1, C1204.1, C1205.1, R1201.1, R1205.2, R1206.1, R1210.1, TP1201.1, U1202.4
+12V: C205.1, C401.1, C404.1, C1801.1, R207.1, R210.2, R212.2, R213.1, TP203.1, U401.10, U401.11, U401.12, U1801.4
+12Vin: C201.1, C202.1, C203.1, D201.1, J201.1, Q201.7, Q201.8, R201.1, R204.1, TP202.1, U201.4
/USB UART Bridge/BRIDGE_USB+: R1207.2, U1202.12
/USB UART Bridge/BRIDGE_USB-: R1208.2, U1202.1
/USB UART Bridge/CONN_USB+: C1207.1, J1201.3, R1207.1, U1203.6
/USB UART Bridge/CONN_USB-: C1208.1, J1201.2, R1208.1, U1203.5
CPU_Trap_LED: R1906.1, U1101.44, U1904.2
Cap_Touch_Power: U1101.13, U1706.4
Error_LED: R1902.1, U1101.43, U1902.2
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C302.2, C303.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C503.2, C505.2, C601.2, C602.2, C603.2, C604.2, C605.2, C703.2, C705.2, C801.2, C802.2, C901.2, C902.2, C903.2, C904.2, C905.2, C906.2, C907.2, C908.2, C909.2, C910.2, C911.2, C912.2, C913.2, C914.2, C915.2, C916.2, C918.2, C920.2, C1001.2, C1003.2, C1005.2, C1201.2, C1202.2, C1203.2, C1204.2, C1205.2, C1206.2, C1207.2, C1208.2, C1209.2, C1302.2, C1303.2, C1401.2, C1402.2, C1403.2, C1404.2, C1501.2, C1502.2, C1503.2, C1504.2, C1505.2, C1506.2, C1507.2, C1508.2, C1509.2, C1510.2, C1511.2, C1512.2, C1513.2, C1514.2, C1601.2, C1602.2, C1603.2, C1604.2, C1605.2, C1702.2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
GNDA_MZ: C917.2, C919.2, C921.2, L902.1, U1101.20
Heartbeat_LED: R1901.1, U1101.57, U1901.2
I2C_SCL: J2001.2, R1102.2, U301.5, U302.2, U502.2, U503.5, U702.2, U703.5, U1101.42, U1301.5, U1302.2, U1401.5, U1502.2, U2001.2
I2C_SDA: J2001.1, R1101.2, U301.6, U302.1, U502.1, U503.6, U503.7, U702.1, U703.6, U1101.41, U1301.6, U1302.1, U1401.6, U1502.3, U2001.1
LCD_BACKLIGHT: R1604.2, U1602.15
LCD_BACKLIGHT_PWM: R1601.1, U1101.6, U1601.2
LCD_CONTRAST: RV1601.2, U1602.3
LCD_PMP_DB0: R1606.1, U1101.58, U1602.7
LCD_PMP_DB1: R1607.1, U1101.61, U1602.8
LCD_PMP_DB2: R1608.1, U1101.62, U1602.9
LCD_PMP_DB3: R1609.1, U1101.63, U1602.10
LCD_PMP_DB4: R1610.1, U1101.64, U1602.11
LCD_PMP_DB5: R1611.1, U1101.1, U1602.12
LCD_PMP_DB6: R1612.1, U1101.2, U1602.13
LCD_PMP_DB7: R1613.1, U1101.3, U1602.14
LCD_PMP_E: R1605.2, U1101.52, U1602.6
LCD_PMP_RS: R1602.1, U1101.30, U1602.4
LCD_PMP_R_W: R1603.1, U1101.53, U1602.5
unnamed: C204.1, R211.2
unnamed: C402.1, D401.1, R406.1
unnamed: C403.1, U401.9
unnamed: C405.1, L401.2, R407.2, R408.1
unnamed: C602.1, U601.8
unnamed: C603.1, C604.1, R606.2, R607.1, U601.1, U601.2
unnamed: C802.1, R803.2, R804.2, R805.2
unnamed: C1001.1, C1003.1, C1005.1, L1001.1, X1001.4
unnamed: C1206.1, U1202.3
unnamed: C1209.1, L1201.2, U1203.1, U1203.3
unnamed: C1401.1, C1402.1, C1403.1, C1404.1, D1401.1, U1401.8
unnamed: C1704.1, U1704.4
unnamed: C1704.2, R1702.2, U1704.3
unnamed: C1706.1, U1702.5, U1704.5, U1704.6
unnamed: C1708.1, R1706.1, U1706.2
unnamed: C1802.1, R1801.1, U1801.5, U1802.5
unnamed: D1201.2, R1210.2
unnamed: D1801.1, U1802.4
unnamed: D1801.2, R1801.2
unnamed: D1802.1, U1803.4
unnamed: D1802.2, R1802.2
unnamed: D1804.1, U1805.4
unnamed: D1804.2, R1804.2
unnamed: D1805.1, U1806.4
unnamed: D1805.2, R1805.2
unnamed: D1901.1, U1901.4
unnamed: D1901.2, R1903.2
unnamed: D1902.1, U1902.4
unnamed: D1902.2, R1904.2
unnamed: D1903.1, U1903.4
unnamed: D1903.2, R1907.2
unnamed: D1904.1, U1904.4
unnamed: D1904.2, R1908.2
unnamed: J1201.1, L1201.1
unnamed: J1201.6, L1202.2
unnamed: L401.1, U401.1, U401.2, U401.3
unnamed: Q201.1, Q201.3
unnamed: Q201.2, R205.2
unnamed: Q201.4, R206.1
unnamed: Q201.5, Q201.6, R209.2, R210.1, U201.6
unnamed: Q401.3, Q402.1, R406.2
unnamed: Q801.1, R801.2, R802.1
unnamed: Q801.3, R803.1
unnamed: R201.2, R202.1, U201.3
unnamed: R202.2, R203.1, U201.2
unnamed: R204.2, U201.8
unnamed: R205.1, R206.2, R211.1, U201.5
unnamed: R410.2, R411.1, U401.5
unnamed: R609.2, R610.1, U601.3
unnamed: R801.1, SW801.2
unnamed: R1002.1, X1001.3
unnamed: R1201.2, R1202.1, U1201.3
unnamed: R1202.2, R1203.1, U1201.4
unnamed: R1206.2, R1209.2, U1203.4
unnamed: R1505.2, U1502.7, U1503.2
unnamed: R1506.2, U1502.6, U1503.3
unnamed: R1604.1, U1601.4
unnamed: R1702.1, SW1702.1
unnamed: R1704.1, R1706.2, U1704.1
PIC32MZ_ICSPCLK: J801.5, U1101.17
PIC32MZ_ICSPDAT: J801.4, U1101.18
PIC32MZ_POSC_EC: R1002.2, R1004.1, U1101.31
PIC32MZ_POSC_EC_Enable: R1001.1, U1101.32, X1001.1
PIC32MZ_REFCLK1: R1006.1, TP1001.1, U1101.47
POS1P8_PGOOD: R601.2, U601.5, U1101.46, U1805.2
POS1P8_RUN: R602.1, U601.7, U1101.49
POS1P8_SNS_OUT+: C704.1, R606.1, U703.1
POS1P8_SNS_OUT-: C704.2, R608.1, U703.2
POS3P3_PGOOD: R405.2, U401.4, U1806.2
POS3P3_POX_ADC: C1506.1, R1503.2, R1504.1, U1101.5
POS3P3_POX_Enable: R1501.1, U1101.15, U1501.3
POS3P3_RUN: Q401.1, R403.1, U401.13
POS3P3_SNS_OUT+: C504.1, R407.1, U503.1
POS3P3_SNS_OUT-: C504.2, R409.1, U503.2
POS5_USB_PGOOD: R1204.2, U1201.1, U1201.6, U1803.2
POS5_USB_SNS+: C1301.1, R1209.1, U1301.1
POS5_USB_SNS-: C1301.2, R1205.1, U1301.2
POS12_PGOOD: R207.2, R208.1, R403.2, U201.7, U1802.2
POS12_SNS+: C301.1, R209.1, U301.1
POS12_SNS-: C301.2, R212.1, U301.2
POX_I2C_Enable: R1502.1, U1101.16, U1502.5
Reset_LED: R1905.2, U1101.56, U1903.2
Telemetry_Config: R2001.2, R2002.1, U1101.45
USB_UART_RX: J2002.1, U1101.50, U1202.7
USB_UART_TX: J2002.2, U1101.51, U1202.10
~PIC32MZ_MCLR: J801.1, R805.1, U1101.9
~POX_INT: R1507.2, U1101.14, U1503.13
~USB_ACTIVE: D1201.1, U1202.6

File hdw/Pulse_Oximeter/Pulse_Oximeter_BOM.xlsx (part):

Item | Qty | Reference(s) | Value | LibPart | Footprint | Datasheet | Ampacity | Baud_Rate | Configuration | Data_Length | Dielectric | Digi-Key PN | Flow_Control | Parity | Stop_Bits | Tolerance | Voltage | Wattage | display_footprint
1 | 51 | C201, C204, C301, C302, C303, C404, C406, C503, C504, C505, C602, C605, C703, C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 | 0.1uF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | X7R | 490-10701-1-ND |  |  |  |  | 50V |  | 402
2 | 14 | C202, C403, C904, C905, C910, C914, C918, C919, C1003, C1506, C1509, C1512, C16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 | 10nF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | X7R | 490-13295-1-ND |  |  |  |  | 50V |  | 402
3 | 11 | C203, C906, C907, C911, C915, C920, C921, C1005, C1510, C1513, C1605 | 1nF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | X7R | 399-1032-1-ND |  |  |  |  | 50V |  | 402
4 | 1 | C205 | 100uF | Custom_Library:CP_Tant_Custom | Capacitors_Tantalum_SMD:CP_Tantalum_Case-X_EIA-7343-43_Reflow |  |  |  |  |  |  | 718-1102-1-ND |  |  |  | 0.1 | 16V |  | 7343
5 | 1 | C401 | 10uF | Custom_Library:C_Custom | Capacitors_SMD:C_1206 |  |  |  |  |  | X7R | 1276-7031-1-ND |  |  |  |  | 25V |  | 1206
6 | 19 | C402, C601, C603, C604, C903, C909, C913, C1401, C1402, C1403, C1501, C1503, C1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 | 10uF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | X5R | 490-13211-1-ND |  |  |  |  | 6.3V |  | 402
7 | 1 | C405 | 100uF | Custom_Library:C_Custom | Capacitors_SMD:C_1206 |  |  |  |  |  | X5R | 587-1963-1-ND |  |  |  |  | 6.3V |  | 1206
8 | 1 | C1204 | 4.7uF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | X5R | 490-14306-1-ND |  |  |  |  | 10V |  | 402
9 | 2 | C1207, C1208 | 47pF | Custom_Library:C_Custom | Capacitors_SMD:C_0402 |  |  |  |  |  | NP0 | 399-17558-1-ND |  |  |  |  | 50V |  | 402
10 | 1 | D201 | 24V | Device:D_TVS_ALT | Diodes_SMD:D_SMA | ~ |  |  |  |  |  | SMAJ24CALFCT-ND
11 | 2 | D401, D1401 | BAT48JFILM | Diode:BAT48JFILM | Diode_SMD:D_SOD-323 | www.st.com/resource/en/datasheet/bat48.pdf |  |  |  |  |  | 497-5711-1-ND
12 | 1 | D1201 | Yellow | Device:LED | LEDs:LED_0402 | ~ |  |  |  |  |  | 1497-1389-1-ND
13 | 5 | D1801, D1802, D1804, D1805, D1901 | Green | Device:LED | LEDs:LED_0402 | ~ |  |  |  |  |  | 1497-1219-1-ND
14 | 3 | D1902, D1903, D1904 | Red | Device:LED | LEDs:LED_0402 | ~ |  |  |  |  |  | 1497-1174-1-ND
15 | 1 | DOC301 | 0x40 | Custom_Library:I2C_Address
16 | 1 | DOC302 | 0x18 | Custom_Library:I2C_Address
17 | 1 | DOC502 | 0x19 | Custom_Library:I2C_Address
18 | 1 | DOC503 | 0x42 | Custom_Library:I2C_Address
19 | 1 | DOC702 | 0x1A | Custom_Library:I2C_Address
20 | 1 | DOC703 | 0x44 | Custom_Library:I2C_Address
21 | 1 | DOC1201 | COM_Port_Settings | Custom_Library:COM_Port_Settings |  |  |  | 115200 bps |  | 8 bit |  |  | None | None | 1
22 | 1 | DOC1301 | 0x45 | Custom_Library:I2C_Address
23 | 1 | DOC1302 | 0x1B | Custom_Library:I2C_Address
24 | 1 | DOC1401 | 0x6B | Custom_Library:I2C_Address
25 | 1 | DOC1501 | 0x57 | Custom_Library:I2C_Address
26 | 1 | DOC2001 | 0x1C | Custom_Library:I2C_Address
27 | 4 | H2301, H2302, H2303, H2304 | MountingHole | Mechanical:MountingHole | MountingHole:MountingHole_3mm | ~
28 | 1 | J201 | +12V IN | Connector:Barrel_Jack_Switch | Connectors:BARREL_JACK | ~ |  |  |  |  |  | CP-202BH-ND
29 | 1 | J801 | PICKIT3 | Connector_Generic:Conn_01x06 | Custom Footprints Library:PICKIT3_Header | ~
30 | 1 | J1201 | USB_B_Mini | Connector:USB_B_Mini | Connectors:USB_Mini-B | ~ |  |  |  |  |  | 732-2109-1-ND
31 | 1 | J2001 | I2C | Connector_Generic:Conn_01x03 | Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical | ~
32 | 1 | J2002 | USB UART | Connector_Generic:Conn_01x03 | Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical | ~
33 | 1 | L401 | 3.3uH | Custom_Library:L_Custom | Inductors_SMD:L_Vishay_IHLP-1212 |  | 2.7A |  |  |  |  | 541-2567-1-ND |  |  |  | 0.2 |  |  | IHLP1212
34 | 5 | L901, L902, L1001, L1201, L1202 | 600R 0.5A | Device:Ferrite_Bead | Inductors_SMD:L_0402 | ~ |  |  |  |  |  | 490-5441-1-ND
35 | 4 | MK2301, MK2302, MK2305, MK2306 | Standoff | Custom_Library:Standoff |  |  |  |  |  |  |  | 1772-1220-ND
36 | 4 | MK2303, MK2304, MK2307, MK2308 | Screw | Custom_Library:Screw |  |  |  |  |  |  |  | 36-9900-ND
37 | 1 | Q201 | Si4946BEY | Custom_Library:Si4946BEY | Package_SO:SOIC-8_3.9x4.9mm_P1.27mm |  |  |  |  |  |  | SI4946BEY-T1-E3CT-ND
38 | 2 | Q401, Q801 | BSS214NW | Transistor_FET:BSS214NW | Package_TO_SOT_SMD:SOT-323_SC-70 | https://www.infineon.com/dgdl/Infineon-BSS214NW-DS-v02_02-en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 |  |  |  |  |  | BSS214NWH6327XTSA1CT-ND
39 | 1 | Q402 | ZXMS6004FFTA | Custom_Library:ZXMS6004FFTA | Package_TO_SOT_SMD:SOT-23 | https://www.diodes.com/assets/Datasheets/ZXMS6004FF.pdf |  |  |  |  |  | ZXMS6004FFCT-ND
40 | 1 | R201 | 6.04M | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-CRCW04026M04FKEDCT-ND |  |  |  | 0.01 |  | 1/16W | 402
41 | 1 | R202 | 86.6k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-86.6KLCT-ND |  |  |  | 0.01 |  | 1/16W | 402
42 | 2 | R203, R204 | 243k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | YAG3070CT-ND |  |  |  | 0.01 |  | 1/16W | 402
43 | 14 | R205, R206, R209, R212, R403, R407, R409, R606, R608, R801, R803, R1205, R1209,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 | 10 | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  | Telemetry |  |  | 541-3964-1-ND |  |  |  | 0.01 |  | 1/16W | 402
44 | 1 | R207 | 13.7k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | RMCF0402FT13K7CT-ND |  |  |  | 0.01 |  | 1/16W | 402
45 | 2 | R208, R211 | 5.23k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | RMCF0402FT5K23CT-ND |  |  |  | 0.01 |  | 1/16W | 402
46 | 4 | R210, R408, R607, R1206 | 0.02 | Custom_Library:R_Custom | Resistors_SMD:R_0612 |  |  |  |  |  |  | P16010CT-ND |  |  |  | 0.01 |  | 1W | 612
47 | 39 | R213, R405, R406, R601, R602, R802, R804, R1001, R1004, R1006, R1101, R1102, R1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 | 10k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  | DNP |  |  | RMCF0402FT10K0CT-ND |  |  |  | 0.01 |  | 1/16W | 402
48 | 1 | R410 | 562k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 311-562KLRCT-ND |  |  |  | 0.01 |  | 1/16W | 402
49 | 1 | R411 | 180k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | A129654CT-ND |  |  |  | 0.01 |  | 1/16W | 402
50 | 1 | R609 | 1.87k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | RMCF0402FT1K87CT-ND |  |  |  | 0.01 |  | 1/16W | 402
51 | 1 | R610 | 1.5k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 311-1.50KLRCT-ND |  |  |  | 0.01 |  | 1/16W | 402
52 | 10 | R805, R1210, R1801, R1802, R1804, R1805, R1903, R1904, R1907, R1908 | 1k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-1.00KLCT-ND |  |  |  | 0.01 |  | 1/16W | 402
53 | 1 | R1002 | 100 | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-100LCT-ND |  |  |  | 0.01 |  | 1/16W | 402
54 | 1 | R1201 | 487k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | RMCF0402FT487KCT-ND |  |  |  | 0.01 |  | 1/16W | 402
55 | 1 | R1202 | 6.04k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-4067-1-ND |  |  |  | 0.01 |  | 1/16W | 402
56 | 1 | R1203 | 40.2k | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-4097-1-ND |  |  |  | 0.01 |  | 1/16W | 402
57 | 2 | R1207, R1208 | 27 | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | 541-4082-1-ND |  |  |  | 0.01 |  | 1/16W | 402
58 | 2 | R1604, R1702 | 499 | Custom_Library:R_Custom | Resistors_SMD:R_0402 |  |  |  |  |  |  | RMCF0402FT499RCT-ND |  |  |  | 0.01 |  | 1/16W | 402
59 | 1 | RV1601 | 10k | Device:R_POT | Potentiometer_SMD:Potentiometer_Vishay_TS53YL_Vertical | ~ |  |  |  |  |  | TS53YL-10KCT-ND
60 | 1 | SW801 | MRST | Switch:SW_Push | Buttons_Switches_THT:SW_PUSH_6mm
61 | 1 | SW1702 | Cap_Touch | Custom_Library:Cap_Touch | Custom Footprints Library:Capacitive_Touch_Pad
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
## Code that names these connections

File rev_b/sfw/U1101_firmware/pulse_oximeter.X/pin_macros.h:

#ifndef _PIN_MACROS_H    /* Guard against multiple inclusion */
#define _PIN_MACROS_H

#include <xc.h>

#define HIGH    1
#define LOW     0

// These pin macros allow for easier manipulation of GPIO with matching
// signal names from the hardware schematic

// Port A
// NO PORT A

// Port B
#define POX_I2C_ENABLE_PIN          LATBbits.LATB0
#define POS3P3_POX_ENABLE_PIN       LATBbits.LATB1
#define POX_INT_PIN                 PORTBbits.RB2
#define CAP_TOUCH_POWER_PIN         PORTBbits.RB3
#define POS12_PGOOD_PIN             PORTBbits.RB10
#define POS5_USB_PGOOD_PIN          PORTBbits.RB11
#define POS3P3_PGOOD_PIN            PORTBbits.RB12
#define nETC_CONFIG_PIN             PORTBbits.RB13
#define PGOOD_LED_SHDN_PIN          LATBbits.LATB14
#define LCD_PMP_RS_PIN              LATBbits.LATB15

// Port C
#define POSC_EC_ENABLE_PIN          LATCbits.LATC15

// Port D
#define POS1P8_PGOOD_PIN            PORTDbits.RD0
#define POS1P8_RUN_PIN              LATDbits.LATD1
#define LCD_PMP_E_PIN               LATDbits.LATD4
#define LCD_R_W_PIN                 LATDbits.LATD5
#define CPU_TRAP_LED_PIN            LATDbits.LATD9
#define ERROR_LED_PIN               LATDbits.LATD10
#define nTELEMETRY_CONFIG_PIN       PORTDbits.RD11

// Port E
// used for LCD parallel bus

// Port F
#define RESET_LED_PIN               LATFbits.LATF0
#define HEARTBEAT_LED_PIN           LATFbits.LATF1

// Port G
#define LCD_BACKLIGHT_PWM_PIN       LATGbits.LATG8

#endif /* _PIN_MACROS_H */

/* *****************************************************************************
 End of File
 */

## Commit log

2020-05-03 update gitignore
2020-05-03 Started schematics
2020-05-03 Continued schematic development
2020-05-06 Added display circuits
2020-05-09 few sch additions
2020-05-09 More sch work
2020-05-09 Added I2C to PIC32MZ
2020-05-10 Added more stuff to sch
2020-05-11 Added SD card slot and backup RTC
2020-05-15 Added mech sheet, more complicated bullshit you dont need
2020-05-15 Added digikey pn's, footprints
2020-05-16 Corrected symbols, first netlist
2020-05-16 a few sch tweaks
2020-05-17 arranged some parts in PCB
2020-05-27 More part arrangements
2020-05-27 More part arranging
2020-05-28 more part groupings
2020-05-28 Finished grouping parts within PCB outline:
2020-05-29 removed SOSC, started routing
2020-05-29 More routing
2020-05-30 Mcu hmore routing, ran autorouter
2020-06-04 More PCB work, generated BOM
2020-06-06 Few silk cleanups, added gerbers
2020-06-17 added bom, removed unused sch sheets
2020-06-17 started firmware project
2020-06-17 Ported a lot of code over, simplified GPIO setup
2020-06-22 ported heartbeat, fixed some stuff, added refclk1 out
2020-06-22 ported USB UART TX, added module macro switch
2020-06-22 ported USB UART RX stuff, fixed some print messages
2020-06-22 Ported error handling, more random stuff
2020-06-23 Ported power savings, prefetch
2020-06-23 ported cause of reset
2020-06-23 added PPS i/o macros for mapping PPS signals
2020-06-23 added some I2C master stuff
2020-06-24 added some I2C stuff
2020-06-26 ported some MCP9804 code to new I2C APIs
2020-06-26 ported some INA219 code
2020-06-26 ported lots of telemetry stuff
2020-06-29 Added ADC stuff
2020-06-29 More ADC stuff, added POX power startup code
2020-06-30 Ported MAX30102 driver code, no algorithm yet
2020-06-30 ported SPO2 algorithm
2020-07-01 Got a lot more MA30102 stuff working, still no SPO2 or HR
2020-07-02 Got MAX polling working, no correct SPO2 or HR yet
2020-07-02 More POX code tweaks, so close
2020-07-03 Fixed TOF ETC bug
2020-07-03 removed debugging NOPs
2020-07-03 Added MAX30102 print status functions
2020-07-09 more POX progress, actually reading values now
2020-07-09 a few telemetry tweaks
2020-07-09 refactored POX DAQ code to be interrupt based, instead of for loop based
2020-07-10 Added code to support PWM dimming of LCD backlight
2020-07-10 Added some basic PMP code
2020-07-14 Added PMP status function
2020-07-14 added some DMA status print stuff
2020-07-14 Finished DMA status code
2020-07-17 Made a few PMP tweaks
2020-07-18 got LCD working iwth bit banging
2020-07-19 removed PMP code, sticking with LCD bit banging
2020-07-19 Added LCD display stuff to POX DAQ callback
2020-07-21 a few LCD cleanups
2020-07-21 Added power cap touch pushbutton code
2020-07-21 added more user interface stuff, wakeup/shutdown code
2020-07-21 changed from bools to keep track of ui state machine to enum
2020-07-21 Made more UI progress
2020-07-22 Added sleep functionality in wakeup/shutdown code
2020-07-22 Pretty much figured out wakeup state machine
2020-07-22 Added some more comprehensive error flags
2020-07-23 LCD String cleanups
2020-07-23 Adjusted schematic to reflect ECO for issue #8
2020-07-23 LCD string optimizations
2020-07-23 added LCD disable in sleep
2020-07-23 more powersaving features
2020-07-25 string tweaks, fmw v 0.9
2020-07-25 added deployable BOM
2020-08-01 Cleaned up schematic, generated PCB renders
2020-08-01 Set TELEMETRY configs to visible in SCH
2020-08-20 Removed unneeded boot screen
2020-08-27 Clarified instruction screen strings
2020-08-29 added FTDI flash image
2020-09-02 Added user guide document
2020-09-06 printable user guide changes
2020-12-10 moved rev A hardware files
2020-12-10 created rev b hardware project
2020-12-10 removed rev a output files, renamed Time of Flight to Platform_ETC
2020-12-10 fixed some component configurations in sch, regenerated netlist
2020-12-11 babies first commit
2020-12-11 changed POX filtering and level shifting
2020-12-11 regenerated PDF
2020-12-11 changed PGOOD LED drivers
2020-12-11 lots of rev B sch progress
2020-12-18 change pushbutton sheet
2020-12-18 lots of rev b changes
2020-12-21 merged, more cleanups
2020-12-21 changed all passives to 0402, cleared digikey pns
2020-12-21 few little tweaks
2020-12-23 removed more unique components, cleaned up SCH
2020-12-23 reworked +3.3V discharge holdup circuit
2020-12-23 annotated schematic
2020-12-23 passed ERC
2020-12-24 fixed PGOOD LED drivers
2020-12-31 changed display sheet to use new LCD
2021-01-01 USB circuit adjustments, add UART dongle header, resolve some open rev B SCH issues
2021-01-01 assigned digikey PNs
2021-01-06 started working on rev B PCB, a few SCH changes
2021-01-12 fixed a few sch issues, more PCB placement
2021-01-13 finished arranging pcb by sheet
2021-01-15 board outline, arranged functional blocks
2021-01-15 started routing
2021-01-16 added POX LED, much more routing
2021-01-22 much more point to point manual routing
2021-01-22 got everything connected
2021-01-23 finished board
2021-01-24 restructured repo, generated rev b BOMs
2021-01-30 added rev_b firmware project
2021-01-30 ported a lot of new code, not building yet though
2021-01-30 commit for new branch creation, pushing to master whoops
2021-01-30 wrote pin macro and gpio setup code
2021-01-30 clock source changes
2021-01-31 moved some I2C code around
2021-01-31 lots of random issues resolved, now building
2021-02-12 got lots of rev b firmware stuff working, made I2C macro configurable
2021-02-13 added POX Power serial command
2021-02-13 finalized ETC hardstrap configurations
2021-02-13 fixed PWM timing source overlap issues
2021-02-13 fixed heartbeat LED PWM issue on shutdown
2021-02-13 added PGOOD LED shutoff in sleep mode
2021-02-13 removed text color from POX DAQ Verbose command
2021-02-13 added some pyhton stuff
2021-02-14 Got python script finding serial device
2021-02-14 script is now receiving pox data, parsing and storing in string list
2021-02-14 have script properly parsing data into lists from serial data feed
2021-02-14 got basic infrared plotting working
2021-02-14 way more plotting functionality working
2021-02-14 more plotting script progress
2021-02-14 finished plotting script
2021-02-22 finishing touches on rev B firmware
2021-02-22 fixed LCD contrast resistors
2021-02-23 added basic pick and place feeders spreadsheet
2021-02-24 more pick and place preparation
2021-03-24 added rev b doc
2022-06-22 Bump numpy from 1.20.1 to 1.22.0 in /rev_b/sfw/scripts
    Bumps [numpy](https://github.com/numpy/numpy) from 1.20.1 to 1.22.0.
    - [Release notes](https://github.com/numpy/numpy/releases)
    - [Changelog](https://github.com/numpy/numpy/blob/main/doc/HOWTO_RELEASE.rst)
    - [Commits](https://github.com/numpy/numpy/compare/v1.20.1...v1.22.0)
    ---
    updated-dependencies:
