# Repository drewsum/pulse_oximeter

File README.md:

A pulse oximeter built around a MAX30102 pox sensor and a PIC32MZ EF MCU

MCU firmware located at sfw/U1101_firmware/ is built using XC32 v2.10 compiler, written with MPLAB X v5.15 IDE, programmed using PICKIT4 via header J801

Used aromring's MAX30102_by_RF library for MAX30102 I2C Driver, heavily modified to work with PIC32MZ and my I2C driver, as well as actually using the MAX30102 INT signal as an IRQ, rather than polling it. Available here: https://github.com/aromring/MAX30102_by_RF

## KiCad design rev_b/hdw/Pulse_Oximeter/Pulse_Oximeter.kicad_pcb

Board: 4 copper layers, 100.0 x 83.0 mm, 286 parts (83 on the bottom side), 131 nets.

Parts:
C201, C404, C602, C1701: 10nF; C_0402
C202, C301, C302, C303, C401, C405, C501, C502, C503, C701, C702, C703, C801, C802, C901, C902, C905, C907, C909, C910, C1001, C1201, C1202, C1204, C1205, C1206, C1208, C1210, C1211, C1301, C1302, C1303, C1404, C1501, C1504, C1508, C1511, C1512, C1513, C1601, C1603, C1702, C1704, C1801, C1802, C1803, C1804, C1901, C1902, C1903, C1904, C2001, C2002: 0.1uF; C_0402
C203: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Reflow
C402, C406, C407: 10uF; C_1206
C403, C601, C603, C903, C904, C906, C908, C911, C912, C1002, C1203, C1401, C1402, C1403, C1502, C1503, C1505, C1506, C1507, C1509, C1510, C1602, C1604, C1605, C1703: 10uF; C_0402
C1207, C1209: 47pF; C_0402
D201: 24V; D_SMA
D401, D1902, D1903, D1904: Red; LED_0402
D1201: Yellow; LED_0402
D1401: BAT48JFILM; D_SOD-323
D1501, D1801, D1802, D1803, D1804, D1901: Green; LED_0402
H2101, H2102, H2103, H2104: MountingHole; MountingHole_3mm
J201: +12V IN; BARREL_JACK
J801: PICKIT4; PICKIT4_Header
J1201: USB_B_Mini; USB_Mini-B
J1202: OSEPP_FTDI_01; PinHeader_1x06_P2.54mm_Vertical
L401: 3.3uH; L_Vishay_IHLP-1212
L901, L902, L1001, L1201, L1202, L1501, L1502: 600R 0.5A; L_0402
Q401, Q402, Q801: BSS214NW; SOT-323_SC-70
R201, R203, R1206, R1207, R1216, R1217: 100k; R_0402
R202, R205, R206, R212, R214, R218, R219, R220, R401, R403, R404, R405, R406, R601, R602, R802, R804, R1001, R1002, R1004, R1101, R1102, R1205, R1501, R1502, R1505, R1506, R1507, R1601, R1602, R1603, R1605, R1606, R1607, R1609, R1610, R1611, R1612, R1613, R1614, R1615, R1703, R1704, R1705, R1801, R1901, R1902, R1905, R1906, R2001, R2003: 10k; R_0402
R204, R215, R216, R217, R805, R1201, R1508, R1701, R1702, R1802, R1803, R1804, R1805, R1903, R1904, R1907, R1908: 1k; R_0402
R207, R213, R409, R414, R605, R610, R1208, R1215, R2002, R2004: 10; R_0402
R208, R410, R606, R1209: 0.02; R_0612
R209, R210, R211, R402, R408, R411, R412, R413, R607, R608, R609, R1210, R1211, R1212, R1218, R1503, R1504, R1608: 0; R_0402
R407, R603, R604, R801, R803, R1003, R1604: 100; R_0402
R415: 562k; R_0402
R416: 180k; R_0402
R1202: 487k; R_0402
R1203: 6.04k; R_0402
R1204: 40.2k; R_0402
R1213, R1214: 27; R_0402
SW801: MRST; SW_PUSH_6mm
SW1701: Cap_Touch; Capacitive_Touch_Pad
TP201: TP; Pin_Header_Angled_1x01_Pitch2.54mm
TP202, TP203: TP_Pad; Test_Point
TP401, TP601, TP1001, TP1201: TP; Test_Point
U201: TPS26600RHFT; QFN-24-1EP_4x5mm_Pitch0.5mm
U301, U502, U702, U1301: INA219BxDCN; SOT-23-8
U302, U501, U701, U1302, U2001: MCP9804; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm
U401, U1504, U1601, U1702, U1801, U1802, U1803, U1804, U1901, U1902, U1903, U1904: 74LVC1G97; SOT-363_SC-70-6
U402: TPS62152; QFN-16-1EP_3x3mm_P0.5mm_EP1.8x1.8mm
U601: TPS7A7200RGTR; QFN-16-1EP_3x3mm_P0.5mm_EP1.75x1.75mm
U1101: PIC32MZ0512EFE064T-I_PT; TQFP-64_10x10mm_P0.5mm
U1201: TLV6700; SOT-23-6
U1202: FT234XD; DFN-12-1EP_3x3mm_Pitch0.45mm
U1203: TXB0102DCU; VSSOP-8_2.4x2.1mm_P0.5mm
U1204: TPD3S014DBVR; SOT-23-6
U1401: DS1683; SOIC-8_3.9x4.9mm_Pitch1.27mm
U1501: TPS22929D; SOT-23-6
U1502: TCA9803; VSSOP-8_3.0x3.0mm_P0.65mm
U1503: MAX30102; Maxim_OLGA-14_3.3x5.6mm_P0.8mm
U1602: Generic 20x04 LCD; 20x04_LCD
U1701: AT42QT1010-TSHR; SOT-23-6
U2002: LTC1694; SOT-23-5
X1001: ASE-8.000MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1.8V: C1504.1, C1505.1, L1502.2, R606.2, R607.2, R608.2, R609.2, R610.2, TP601.1, U601.1, U1502.8
+3.3VA_MZ: C910.1, C912.1, L901.1, U1101.19
+3.3V_POX: L1501.2, R1505.1, U1501.1
+3.3V_USB: C1201.1, C1206.1, C1210.1, C1211.1, J1202.4, R1216.1, R1217.1, R1218.2, U1202.3, U1202.9, U1203.7
+3V3: C302.1, C303.1, C401.1, C501.1, C503.1, C601.1, C701.1, C703.1, C801.1, C901.1, C902.1, C903.1, C904.1, C905.1, C906.1, C907.1, C908.1, C909.1, C911.1, C1204.1, C1208.1, C1302.1, C1303.1, C1501.1, C1502.1, C1503.1, C1513.1, C1601.1, C1602.1, C1603.1, C1604.1, C1605.1, C1702.1, C1704.1, C1801.1, C1802.1, C1803.1, C1804.1, C1901.1, C1902.1, C1903.1, C1904.1, C2001.1, C2002.1, D1401.2, J801.2, L901.2, L1001.2, R403.1, R407.1, R410.2, R411.2, R412.2, R413.2, R414.2, R415.1, R601.1, R804.1, R1101.1, R1102.1, R1205.1, R1206.1, R1207.1, R1507.1, R1508.1, R1603.1, R1612.1, R1802.1, R1803.1, R1804.1, R1805.1, R1903.1, R1904.1, R1905.1, R1907.1, R1908.1, R2001.1, R2003.1, SW801.1, TP401.1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
+5V_USB: C1202.1, C1203.1, C1205.1, R1201.1, R1202.1, R1208.2, R1209.1, R1210.1, R1211.1, R1212.1, TP1201.1, U1202.4
+12V: C203.1, C402.1, C405.1, R208.2, R209.2, R210.2, R211.2, R213.2, R215.1, R405.1, TP203.1, U402.10, U402.11, U402.12
+12Vin: C202.1, D201.1, J201.1, R201.1, R203.1, R206.1, TP202.1, U201.8, U201.9
/USB UART Bridge/BRIDGE_USB+: R1213.2, U1202.12
/USB UART Bridge/BRIDGE_USB-: R1214.2, U1202.1
/USB UART Bridge/CONN_USB+: C1207.1, J1201.3, R1213.1, U1204.6
/USB UART Bridge/CONN_USB-: C1209.1, J1201.2, R1214.1, U1204.5
CPU_Trap_LED: R1906.1, U1101.43, U1904.6
Cap_Touch_Power: R1705.1, U1101.13, U1702.4
Error_LED: R1902.1, U1101.44, U1902.6
GND: C202.2, C203.2, C302.2, C303.2, C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C501.2, C503.2, C601.2, C602.2, C603.2, C701.2, C703.2, C801.2, C802.2, C901.2, C902.2, C903.2, C904.2, C905.2, C906.2, C907.2, C908.2, C909.2, C911.2, C1001.2, C1002.2, C1201.2, C1202.2, C1203.2, C1204.2, C1205.2, C1206.2, C1207.2, C1208.2, C1209.2, C1210.2, C1211.2, C1302.2, C1303.2, C1401.2, C1402.2, C1403.2, C1404.2, C1501.2, C1502.2, C1503.2, C1504.2, C1505.2, C1506.2, C1507.2, C1508.2, C1509.2, C1510.2, C1511.2, C1512.2, C1513.2, C1601.2, C1602.2, C1603.2, C1604.2, C1605.2, C1702.2, C1703.2, C1704.2, C1801.2, C1802.2, C1803.2, C1804.2, C1901.2, C1902.2, C1903.2, C1904.2, C2001.2, C2002.2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
GNDA_MZ: C910.2, C912.2, L902.1, U1101.20
Heartbeat_LED: R1901.1, U1101.57, U1901.6
I2C_SCL: R1102.2, R1503.1, U301.5, U302.2, U501.2, U502.5, U701.2, U702.5, U1101.42, U1301.5, U1302.2, U1401.5, U1502.2, U2001.2, U2002.4
I2C_SDA: R1101.2, R1504.1, U301.6, U302.1, U501.1, U502.6, U502.7, U701.1, U702.6, U1101.41, U1301.6, U1302.1, U1401.6, U1502.3, U2001.1, U2002.5
LCD_BACKLIGHT: R1608.2, U1602.15
LCD_BACKLIGHT_PWM: R1601.1, U1101.6, U1601.1
LCD_CONTRAST: R1603.2, R1604.1, U1602.3
LCD_PMP_DB0: R1606.1, U1101.58, U1602.7
LCD_PMP_DB1: R1607.1, U1101.61, U1602.8
LCD_PMP_DB2: R1609.1, U1101.62, U1602.9
LCD_PMP_DB3: R1610.1, U1101.63, U1602.10
LCD_PMP_DB4: R1611.1, U1101.64, U1602.11
LCD_PMP_DB5: R1613.1, U1101.1, U1602.12
LCD_PMP_DB6: R1614.1, U1101.2, U1602.13
LCD_PMP_DB7: R1615.1, U1101.3, U1602.14
LCD_PMP_E: R1612.2, U1101.52, U1602.6
LCD_PMP_RS: R1602.1, U1101.30, U1602.4
LCD_PMP_R_W: R1605.1, U1101.53, U1602.5
unnamed: C201.1, U201.20
unnamed: C201.2, R202.2, R205.2, R212.2, R214.2, U201.15, U201.25
unnamed: C403.1, D401.1, R404.1, R406.1
unnamed: C404.1, U402.9
unnamed: C406.1, C407.1, L401.2, R409.2, R410.1, R411.1, R412.1, R413.1
unnamed: C602.1, U601.11
unnamed: C603.1, R603.1, R604.1, R605.2, R606.1, R607.1, R608.1, R609.1, U601.15, U601.16
unnamed: C802.1, R803.1, R804.2, R805.2
unnamed: C1001.1, C1002.1, L1001.1, X1001.4
unnamed: C1401.1, C1402.1, C1403.1, C1404.1, D1401.1, U1401.8
unnamed: C1506.1, C1509.1, C1511.1, L1501.1, U1503.9, U1503.10
unnamed: C1507.1, C1510.1, C1512.1, L1502.1, U1503.11
unnamed: C1701.1, U1701.4
unnamed: C1701.2, R1701.1, R1702.1, U1701.3
unnamed: C1703.1, R1704.1, U1702.1
unnamed: D401.2, R405.2
unnamed: D1201.2, R1201.2
unnamed: D1501.1, U1504.4
unnamed: D1501.2, R1508.2
unnamed: D1801.1, U1801.4
unnamed: D1801.2, R1802.2
unnamed: D1802.1, U1802.4
unnamed: D1802.2, R1803.2
unnamed: D1803.1, U1803.4
unnamed: D1803.2, R1804.2
unnamed: D1804.1, U1804.4
unnamed: D1804.2, R1805.2
unnamed: D1901.1, U1901.4
unnamed: D1901.2, R1903.2
unnamed: D1902.1, U1902.4
unnamed: D1902.2, R1904.2
unnamed: D1903.1, U1903.4
unnamed: D1903.2, R1907.2
unnamed: D1904.1, U1904.4
unnamed: D1904.2, R1908.2
unnamed: J1201.1, L1201.1
unnamed: J1201.6, L1202.2
unnamed: L401.1, U402.1, U402.2, U402.3
unnamed: L1201.2, U1204.1, U1204.3
unnamed: Q401.3, Q402.1, R406.2
unnamed: Q402.3, R407.2
unnamed: Q801.1, R801.1, R802.1
unnamed: Q801.3, R803.2
unnamed: R201.2, R203.2, R204.1, U201.10
unnamed: R202.1, R204.2, R205.1, U201.12
unnamed: R206.2, U201.14
unnamed: R207.2, R208.1, R209.1, R210.1, R211.1, U201.23, U201.24
unnamed: R212.1, U201.19
unnamed: R214.1, U201.18
unnamed: R215.2, R216.1
unnamed: R216.2, R217.1
unnamed: R217.2, R218.1
unnamed: R403.2, U401.6, U402.4
unnamed: R408.1, R415.2, R416.1, U402.5
unnamed: R801.2, SW801.2
unnamed: R1003.1, X1001.3
unnamed: R1202.2, R1203.1, U1201.3
unnamed: R1203.2, R1204.1, U1201.4
unnamed: R1209.2, R1210.2, R1211.2, R1212.2, R1215.2, U1204.4
unnamed: R1503.2, U1502.7, U1503.2
unnamed: R1504.2, U1502.6, U1503.3
unnamed: R1608.1, U1601.4
unnamed: R1701.2, R1702.2, SW1701.1
unnamed: R1703.1, R1704.2, U1701.1
PGOOD_LED_SHDN: R1801.1, U1101.29, U1801.3, U1802.3, U1803.3, U1804.3
PIC32MZ_ICSPCLK: J801.5, U1101.17
PIC32MZ_ICSPDAT: J801.4, U1101.18
PIC32MZ_POSC_EC: R1003.2, R1004.1, U1101.31
PIC32MZ_POSC_EC_Enable: R1002.1, U1101.32, X1001.1
PIC32MZ_REFCLK1: R1001.1, TP1001.1, U1101.47
POS1P8_PGOOD: R601.2, U601.3, U1101.46, U1803.6
POS1P8_RUN: R602.1, U601.12, U1101.49
POS1P8_SNS_OUT+: C702.1, R605.1, U702.1
POS1P8_SNS_OUT-: C702.2, R610.1, U702.2
POS3P3_PGOOD: R401.1, U401.4, U1101.27, U1804.6
POS3P3_POX_ADC: C1508.1, R1505.2, R1506.1, U1101.5
POS3P3_POX_Enable: R1501.1, U1101.15, U1501.3, U1504.6
POS3P3_RUN: Q401.1, R402.2, U401.3, U402.13
POS3P3_SNS_OUT+: C502.1, R409.1, U502.1
POS3P3_SNS_OUT-: C502.2, R414.1, U502.2
POS5_USB_PGOOD: R1205.2, R1218.1, U1101.24, U1201.1, U1201.6, U1203.6, U1802.6
POS5_USB_SNS+: C1301.1, R1215.1, U1301.1
POS5_USB_SNS-: C1301.2, R1208.1, U1301.2
POS12_PGOOD: R218.2, R219.1, R220.1, R402.1, U201.22, U1101.23, U1801.6
POS12_SNS+: C301.1, R207.1, U301.1
POS12_SNS-: C301.2, R213.1, U301.2
POX_I2C_Enable: R1502.1, U1101.16, U1502.5
Reset_LED: R1905.2, U1101.56, U1903.6
USB_UART_RX: R1207.2, U1101.50, U1203.5
USB_UART_RX_BUF: J1202.3, R1216.2, U1202.7, U1203.8
USB_UART_TX: R1206.2, U1101.51, U1203.4
USB_UART_TX_BUF: J1202.2, R1217.2, U1202.10, U1203.1
~ETC_Config: R2003.2, R2004.1, U1101.28
~PIC32MZ_MCLR: J801.1, R805.1, U1101.9
~POX_INT: R1507.2, U1101.14, U1503.13, U1504.3
~Telemetry_Config: R2001.2, R2002.1, U1101.45
~USB_ACTIVE: D1201.1, U1202.6

File rev_b/hdw/Pulse_Oximeter/Pulse_Oximeter_bom_B.xlsx:

References | Value | Quantity Per PCB | Digi-Key PN | Configuration
C1207 C1209 | 47pF | 2 | 311-3783-1-ND | USB
C201 C404 C602 C1701 | 10nF | 4 | 399-3066-1-ND
C202 C401 C405 C801 C802 C901 C902 C905 C907 C909 C910 C1001 C1208 C1210 C1211 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 | 0.1uF | 33 | 490-10698-1-ND
C1201 C1202 C1204 C1205 C1206 | 0.1uF | 5 | 490-10698-1-ND | USB
C301 C302 C303 C501 C502 C503 C701 C702 C703 C1301 C1302 C1303 C2001 | 0.1uF | 13 | 490-10698-1-ND | Telemetry
C1404 | 0.1uF | 1 | 490-10698-1-ND | ETC
C2002 | 0.1uF | 1 | 490-10698-1-ND | DNP
C403 C601 C603 C903 C904 C906 C908 C911 C912 C1002 C1502 C1503 C1505 C1506 C150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 | 10uF | 21 | 1276-6830-1-ND
C1203 | 10uF | 1 | 1276-6830-1-ND | USB
C1401 C1402 C1403 | 10uF | 3 | 1276-6830-1-ND | ETC
C402 C406 C407 | 10uF | 3 | 1276-1181-1-ND
C203 | 100uF | 1 | 718-1102-1-ND
D201 | 24V | 1 | SMAJ24CALFCT-ND | DNP
D1401 | BAT48JFILM | 1 | 497-5711-1-ND | ETC
D1501 D1801 D1802 D1803 D1804 D1901 | Green | 6 | 1497-1219-1-ND
D401 D1902 D1903 D1904 | Red | 4 | 1497-1174-1-ND
D1201 | Yellow | 1 | 1497-1198-1-ND | USB
J201 | +12V IN | 1
J1202 | OSEPP_FTDI_01 | 1 |  | ~USB
J801 | PICKIT4 | 1
J1201 | USB_B_Mini | 1 | 732-2109-1-ND | USB
L401 | 3.3uH | 1 | 541-2567-1-ND
L1001 | 600R 0.5A | 1 | 490-5441-1-ND | DNP
L1201 L1202 | 600R 0.5A | 2 | 490-5441-1-ND | USB
L901 L902 L1501 L1502 | 600R 0.5A | 4 | 490-5441-1-ND
MK2103 MK2104 MK2107 MK2108 | Screw | 4 | 36-9900-ND
MK2101 MK2102 MK2105 MK2106 | Standoff | 4 | 1772-1910-ND
Q401 Q402 Q801 | BSS214NW | 3 | BSS214NWH6327XTSA1CT-ND
R209 R210 R211 R411 R412 R413 R607 R608 R609 R1210 R1211 R1212 | 0 | 12 | 2019-RK73Z1ETTPCT-ND | ~Telemetry
R1218 | 0 | 1 | 2019-RK73Z1ETTPCT-ND | ~USB
R402 R408 R1503 R1504 R1608 | 0 | 5 | 2019-RK73Z1ETTPCT-ND
R208 R410 R606 R1209 | 0.02 | 4 | P16010CT-ND | Telemetry
R207 R213 R409 R414 R605 R610 R1208 R1215 R2002 | 10 | 9 | RMCF0402FT10R0CT-ND | Telemetry
R2004 | 10 | 1 | RMCF0402FT10R0CT-ND | ETC
R1213 R1214 | 27 | 2 | RMCF0402FT27R0CT-ND | USB
R407 R603 R604 R801 R803 R1003 R1604 | 100 | 7 | RMCF0402FT100RCT-ND
R1201 | 1k | 1 | RMCF0402FT1K00CT-ND | USB
R204 R215 R216 R217 R805 R1508 R1701 R1702 R1802 R1803 R1804 R1805 R1903 R1904 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 | 1k | 16 | RMCF0402FT1K00CT-ND
R1203 | 6.04k | 1 | RMCF0402FT6K04CT-ND | USB
R202 R205 R206 R212 R214 R218 R219 R220 R401 R403 R404 R405 R406 R601 R602 R802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 | 10k | 49 | RMCF0402FT10K0CT-ND
R1002 | 10k | 1 | RMCF0402FT10K0CT-ND | DNP
R1205 | 10k | 1 | RMCF0402FT10K0CT-ND | USB
R1204 | 40.2k | 1 | 311-40.2KLRCT-ND | USB
R201 R203 R1206 R1207 R1216 R1217 | 100k | 6 | RMCF0402FT100KCT-ND
R416 | 180k | 1 | RMCF0402FT180KCT-ND | DNP
R1202 | 487k | 1 | RMCF0402FT487KCT-ND | USB
R415 | 562k | 1 | RMCF0402FT562KCT-ND | DNP
SW1701 | Cap_Touch | 1
SW801 | MRST | 1
U1504 U1801 U1802 U1803 U1804 | 74LVC1G97 | 5 | 296-SN74LVC1G97DCK3CT-ND
U1601 U1702 | 74LVC1G97 | 2 | 296-SN74LVC1G97DCK3CT-ND
U1901 U1902 U1903 U1904 | 74LVC1G97 | 4 | 296-SN74LVC1G97DCK3CT-ND
U401 | 74LVC1G97 | 1 | 296-SN74LVC1G97DCK3CT-ND
U1701 | AT42QT1010-TSHR | 1 | AT42QT1010-TSHRCT-ND
U1401 | DS1683 | 1 | DS1683S+-ND | ETC
U1202 | FT234XD | 1 | 768-1178-1-ND | USB
U1602 | Generic 20x04 LCD | 1
U301 U502 U702 U1301 | INA219BxDCN | 4 | 296-46420-1-ND | Telemetry
U2002 | LTC1694 | 1 | LTC1694CS5#TRPBFCT-ND | DNP
U1503 | MAX30102 | 1 | MAX30102EFD+-ND
U302 U501 U701 U1302 U2001 | MCP9804 | 5 | MCP9804T-E/MCCT-ND | Telemetry
U1101 | PIC32MZ0512EFE064T-I_PT | 1 | PIC32MZ0512EFE064T-I/PTCT-ND
U1502 | TCA9803 | 1 | 296-46573-1-ND | DNP
U1201 | TLV6700 | 1 | 296-51696-1-ND | USB
U1204 | TPD3S014DBVR | 1 | 296-38835-1-ND | USB
U1501 | TPS22929D | 1 | 296-38579-1-ND
U201 | TPS26600RHFT | 1 | 296-45478-1-ND
U402 | TPS62152 | 1 | 296-43621-1-ND
U601 | TPS7A7200RGTR | 1 | 296-40979-2-ND
U1203 | TXB0102DCU | 1 | 296-22862-1-ND
X1001 | ASE-8.000MHz | 1 | 535-9558-1-ND | DNP
