File: hdw/Pulse_Oximeter/USB_Telemetry.sch (KiCad schematic (older format))
At the start: 7 parts

Commit message: Added digikey pn's, footprints
Parts:
- gave numbers to parts that had none: 7
Changed lines of the file:
@@
 Sheet 13 23
 Title "Pulse Oximeter"
-Date ""
+Date "2019-01-03"
 Rev "A"
 Comp "Drew Maatman"
@@
 AR Path="/5E0A0E29/5E2AA99E" Ref="U?"  Part="1"
 AR Path="/5E052856/5E2AA99E" Ref="U?"  Part="1"
-AR Path="/5EAE2FAC/5E2AA99E" Ref="U?"  Part="1"
-F 0 "U?" H 4860 4990 50  0000 C CNN
+AR Path="/5EAE2FAC/5E2AA99E" Ref="U1302"  Part="1"
+F 0 "U1302" H 4860 4990 50  0000 C CNN
 F 1 "MCP9804" H 5510 4990 50  0000 C CNN
 F 2 "Package_DFN_QFN:DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm" H 4010 4040 50  0001 C CNN
@@
 AR Path="/5E0A0E29/5E2AA9A2" Ref="C?"  Part="1"
 AR Path="/5E052856/5E2AA9A2" Ref="C?"  Part="1"
-AR Path="/5EAE2FAC/5E2AA9A2" Ref="C?"  Part="1"
-F 0 "C?" H 5135 5790 50  0000 L CNN
+AR Path="/5EAE2FAC/5E2AA9A2" Ref="C1303"  Part="1"
+F 0 "C1303" H 5135 5790 50  0000 L CNN
 F 1 "0.1uF" H 5135 5590 50  0000 L CNN
 F 2 "Capacitors_SMD:C_0402" H 5148 5540 50  0001 C CNN
@@
 AR Path="/5E0A0E29/5E200B17" Ref="C?"  Part="1"
 AR Path="/5E052856/5E200B17" Ref="C?"  Part="1"
-AR Path="/5EAE2FAC/5E200B17" Ref="C?"  Part="1"
-F 0 "C?" H 5135 3170 50  0000 L CNN
+AR Path="/5EAE2FAC/5E200B17" Ref="C1302"  Part="1"
+F 0 "C1302" H 5135 3170 50  0000 L CNN
 F 1 "0.1uF" H 5135 2970 50  0000 L CNN
 F 2 "Capacitors_SMD:C_0402" H 5148 2920 50  0001 C CNN
@@
 AR Path="/5E0A0E29/5E200B36" Ref="C?"  Part="1"
 AR Path="/5E052856/5E200B36" Ref="C?"  Part="1"
-AR Path="/5EAE2FAC/5E200B36" Ref="C?"  Part="1"
-F 0 "C?" H 4255 2190 50  0000 L CNN
+AR Path="/5EAE2FAC/5E200B36" Ref="C1301"  Part="1"
+F 0 "C1301" H 4255 2190 50  0000 L CNN
 F 1 "0.1uF" H 4255 1990 50  0000 L CNN
 F 2 "Capacitors_SMD:C_0402" H 4268 1940 50  0001 C CNN
@@
 	3790 1860 4230 1860
 $Comp
-L Analog_ADC:INA219BxDCN U?
+L Analog_ADC:INA219BxDCN U1301
 U 1 1 5E200B53
 P 5110 2100
-F 0 "U?" H 4860 2450 50  0000 C CNN
+F 0 "U1301" H 4860 2450 50  0000 C CNN
 F 1 "INA219BxDCN" H 5360 2450 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:SOT-23-8" H 5760 1750 50  0001 C CNN
@@
 POS5_USB_SNS+
 $Comp
-L power:GND #PWR?
+L power:GND #PWR01302
 U 1 1 5EB928E1
 P 5110 2500
-F 0 "#PWR?" H 5110 2250 50  0001 C CNN
+F 0 "#PWR01302" H 5110 2250 50  0001 C CNN
 F 1 "GND" H 5110 2350 50  0000 C CNN
 F 2 "" H 5110 2500 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR?
+L power:GND #PWR01304
 U 1 1 5EB92D79
 P 5110 3220
-F 0 "#PWR?" H 5110 2970 50  0001 C CNN
+F 0 "#PWR01304" H 5110 2970 50  0001 C CNN
 F 1 "GND" H 5110 3070 50  0000 C CNN
 F 2 "" H 5110 3220 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR?
+L power:GND #PWR01306
 U 1 1 5EB9320A
 P 5110 5120
-F 0 "#PWR?" H 5110 4870 50  0001 C CNN
+F 0 "#PWR01306" H 5110 4870 50  0001 C CNN
 F 1 "GND" H 5110 4970 50  0000 C CNN
 F 2 "" H 5110 5120 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:GND #PWR?
+L power:GND #PWR01308
 U 1 1 5EB93821
 P 5110 5840
-F 0 "#PWR?" H 5110 5590 50  0001 C CNN
+F 0 "#PWR01308" H 5110 5590 50  0001 C CNN
 F 1 "GND" H 5110 5690 50  0000 C CNN
 F 2 "" H 5110 5840 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01307
 U 1 1 5EB93D83
 P 5110 5540
-F 0 "#PWR?" H 5110 5390 50  0001 C CNN
+F 0 "#PWR01307" H 5110 5390 50  0001 C CNN
 F 1 "+3.3V" H 5110 5680 50  0000 C CNN
 F 2 "" H 5110 5540 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01305
 U 1 1 5EB94277
 P 5110 4040
-F 0 "#PWR?" H 5110 3890 50  0001 C CNN
+F 0 "#PWR01305" H 5110 3890 50  0001 C CNN
 F 1 "+3.3V" H 5110 4180 50  0000 C CNN
 F 2 "" H 5110 4040 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01303
 U 1 1 5EB94BE3
 P 5110 2920
-F 0 "#PWR?" H 5110 2770 50  0001 C CNN
+F 0 "#PWR01303" H 5110 2770 50  0001 C CNN
 F 1 "+3.3V" H 5110 3060 50  0000 C CNN
 F 2 "" H 5110 2920 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01301
 U 1 1 5EB95503
 P 5110 1700
-F 0 "#PWR?" H 5110 1550 50  0001 C CNN
+F 0 "#PWR01301" H 5110 1550 50  0001 C CNN
 F 1 "+3.3V" H 5110 1840 50  0000 C CNN
 F 2 "" H 5110 1700 50  0001 C CNN
@@
 AR Path="/5EAE2DDC/5EC33AD2" Ref="DOC?"  Part="1"
 AR Path="/5EAE2E6F/5EC33AD2" Ref="DOC?"  Part="1"
-AR Path="/5EAE2FAC/5EC33AD2" Ref="DOC?"  Part="1"
-F 0 "DOC?" H 6010 3190 60  0001 C CNN
+AR Path="/5EAE2FAC/5EC33AD2" Ref="DOC1301"  Part="1"
+F 0 "DOC1301" H 6010 3190 60  0001 C CNN
 F 1 "0x45" H 5560 2940 60  0000 L CNN
 F 2 "" H 6010 3290 60  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01310
 U 1 1 5EC33D87
 P 5510 2300
-F 0 "#PWR?" H 5510 2150 50  0001 C CNN
+F 0 "#PWR01310" H 5510 2150 50  0001 C CNN
 F 1 "+3.3V" V 5510 2440 50  0000 L CNN
 F 2 "" H 5510 2300 50  0001 C CNN
@@
 $EndComp
 $Comp
-L power:+3.3V #PWR?
+L power:+3.3V #PWR01309
 U 1 1 5EC34469
 P 5510 2200
-F 0 "#PWR?" H 5510 2050 50  0001 C CNN
+F 0 "#PWR01309" H 5510 2050 50  0001 C CNN
 F 1 "+3.3V" V 5510 2340 50  0000 L CNN
 F 2 "" H 5510 2200 50  0001 C CNN
@@
 AR Path="/5EAE2DDC/5EC3977D" Ref="DOC?"  Part="1"
 AR Path="/5EAE2E6F/5EC3977D" Ref="DOC?"  Part="1"
-AR Path="/5EAE2FAC/5EC3977D" Ref="DOC?"  Part="1"
-F 0 "DOC?" H 6010 5810 60  0001 C CNN
+AR Path="/5EAE2FAC/5EC3977D" Ref="DOC1302"  Part="1"
+F 0 "DOC1302" H 6010 5810 60  0001 C CNN
 F 1 "0x1B" H 5560 5560 60  0000 L CNN
 F 2 "" H 6010 5910 60  0001 C CNN
@@
 P 5510 4840
 AR Path="/5EAE2DDC/5EC39789" Ref="#PWR?"  Part="1"
-AR Path="/5EAE2FAC/5EC39789" Ref="#PWR?"  Part="1"
-F 0 "#PWR?" H 5510 4590 50  0001 C CNN
+AR Path="/5EAE2FAC/5EC39789" Ref="#PWR01313"  Part="1"
+F 0 "#PWR01313" H 5510 4590 50  0001 C CNN
 F 1 "GND" V 5510 4690 50  0000 R CNN
 F 2 "" H 5510 4840 50  0001 C CNN
@@
 AR Path="/5EAE2DDC/5EC3978F" Ref="#PWR?"  Part="1"
 AR Path="/5EAE2E6F/5EC3978F" Ref="#PWR?"  Part="1"
-AR Path="/5EAE2FAC/5EC3978F" Ref="#PWR?"  Part="1"
-F 0 "#PWR?" H 5510 4590 50  0001 C CNN
+AR Path="/5EAE2FAC/5EC3978F" Ref="#PWR01312"  Part="1"
+F 0 "#PWR01312" H 5510 4590 50  0001 C CNN
 F 1 "+3.3V" V 5510 4880 50  0000 L CNN
 F 2 "" H 5510 4740 50  0001 C CNN
@@
 AR Path="/5EAE2DDC/5EC398CD" Ref="#PWR?"  Part="1"
 AR Path="/5EAE2E6F/5EC398CD" Ref="#PWR?"  Part="1"
-AR Path="/5EAE2FAC/5EC398CD" Ref="#PWR?"  Part="1"
-F 0 "#PWR?" H 5510 4490 50  0001 C CNN
+AR Path="/5EAE2FAC/5EC398CD" Ref="#PWR01311"  Part="1"
+F 0 "#PWR01311" H 5510 4490 50  0001 C CNN
 F 1 "+3.3V" V 5510 4780 50  0000 L CNN
 F 2 "" H 5510 4640 50  0001 C CNN
