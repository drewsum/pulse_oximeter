File: hdw/Pulse_Oximeter/PGOOD_LEDs.sch (KiCad schematic (older format))
At the start: 8 parts

Commit message: Continued schematic development
Parts:
- removed C?: 0.1uF, Capacitors_SMD:C_0402, symbol Custom_Library:C_Custom
- removed D?: Green, LEDs:LED_0402, symbol Device:LED
- removed R?: 1k, Resistors_SMD:R_0402, symbol Custom_Library:R_Custom
- removed U?: 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom_Library:74LVC1G97_Power_NOT
- added C? (x4): 0.1uF, Capacitors_SMD:C_0603, symbol Custom_Library:C_Custom
- added C?: 4.7uF, Capacitors_SMD:C_0805, symbol Custom_Library:C_Custom
- added D? (x4): Green, LEDs:LED_0603, symbol Device:LED
- added R? (x4): 1k, Resistors_SMD:R_0603, symbol Custom_Library:R_Custom
- added U? (x4): 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom_Library:74LVC1G97_Power_NOT
- added U?: TPS71533, Package_TO_SOT_SMD:SOT-353_SC-70-5, symbol Regulator_Linear:TPS71533__SC70
- C?: footprint Capacitors_SMD:C_0402 -> Capacitors_SMD:C_0603; Digi-Key PN 490-10701-1-ND -> 311-1344-1-ND; display_footprint 0402 -> 0603
- D?: footprint LEDs:LED_0402 -> LEDs:LED_0603; Digi-Key PN 1497-1219-1-ND -> 160-1446-1-ND
- R?: footprint Resistors_SMD:R_0402 -> Resistors_SMD:R_0603; Digi-Key PN 541-1.00KLCT-ND -> RMCF0603FT1K00CT-ND; Wattage 1/16W -> 1/10W; display_footprint 0402 -> 0603
Connections:
- net labels added: +12V, POS12_PGOOD, POS1P8_PGOOD
- net labels removed: +5V_USB, GND_USB
- wire segments 4 -> 19
Other:
- moved on the sheet: C?, D?, R?

Commit message: Added display circuits
Parts:
- removed U? (x5): 74LVC1G97, Package_TO_SOT_SMD:SOT-363_SC-70-6, symbol Custom_Library:74LVC1G97_Power_NOT
Changed lines of the file:
@@
 EESchema Schematic File Version 4
+LIBS:Pulse_Oximeter-cache
 EELAYER 30 0
 EELAYER END
@@
 POS5_USB_PGOOD
 $Comp
-L Custom_Library:74LVC1G97_Power_NOT U?
-U 1 1 5E4A38CE
-P 4980 2870
-AR Path="/5CB7A8BC/5E4A38CE" Ref="U?"  Part="1"
-AR Path="/5CB7A8C3/5E4A38CE" Ref="U?"  Part="1"
-AR Path="/5EAE4ADE/5E4A38CE" Ref="U?"  Part="1"
-F 0 "U?" H 5040 3020 50  0000 L CNN
-F 1 "74LVC1G97" H 5040 2720 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-363_SC-70-6" H 5030 2870 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" H 5030 2870 50  0001 C CNN
-F 4 "296-15582-1-ND" H 4980 2870 50  0001 C CNN "Digi-Key PN"
-	1    4980 2870
-	1    0    0    -1
-$EndComp
-$Comp
-L Custom_Library:74LVC1G97_Power_NOT U?
-U 1 1 5E4A4421
-P 6980 2870
-AR Path="/5CB7A8BC/5E4A4421" Ref="U?"  Part="1"
-AR Path="/5CB7A8C3/5E4A4421" Ref="U?"  Part="1"
-AR Path="/5EAE4ADE/5E4A4421" Ref="U?"  Part="1"
-F 0 "U?" H 7040 3020 50  0000 L CNN
-F 1 "74LVC1G97" H 7040 2720 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-363_SC-70-6" H 7030 2870 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" H 7030 2870 50  0001 C CNN
-F 4 "296-15582-1-ND" H 6980 2870 50  0001 C CNN "Digi-Key PN"
-	1    6980 2870
-	1    0    0    -1
-$EndComp
-$Comp
-L Custom_Library:74LVC1G97_Power_NOT U?
-U 1 1 5E4A5210
-P 8980 2870
-AR Path="/5CB7A8BC/5E4A5210" Ref="U?"  Part="1"
-AR Path="/5CB7A8C3/5E4A5210" Ref="U?"  Part="1"
-AR Path="/5EAE4ADE/5E4A5210" Ref="U?"  Part="1"
-F 0 "U?" H 9040 3020 50  0000 L CNN
-F 1 "74LVC1G97" H 9040 2720 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-363_SC-70-6" H 9030 2870 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" H 9030 2870 50  0001 C CNN
-F 4 "296-15582-1-ND" H 8980 2870 50  0001 C CNN "Digi-Key PN"
-	1    8980 2870
-	1    0    0    -1
-$EndComp
-$Comp
-L Custom_Library:74LVC1G97_Power_NOT U?
-U 1 1 5E4A7AA3
-P 2980 4370
-AR Path="/5CB7A8BC/5E4A7AA3" Ref="U?"  Part="1"
-AR Path="/5CB7A8C3/5E4A7AA3" Ref="U?"  Part="1"
-AR Path="/5EAE4ADE/5E4A7AA3" Ref="U?"  Part="1"
-F 0 "U?" H 3040 4520 50  0000 L CNN
-F 1 "74LVC1G97" H 3040 4220 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-363_SC-70-6" H 3030 4370 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" H 3030 4370 50  0001 C CNN
-F 4 "296-15582-1-ND" H 2980 4370 50  0001 C CNN "Digi-Key PN"
-	1    2980 4370
-	1    0    0    -1
-$EndComp
-$Comp
 L Regulator_Linear:TPS71533__SC70 U?
 U 1 1 5E4D26A0
@@
 Wire Wire Line
 	2570 1950 2980 1950
-$Comp
-L Custom_Library:74LVC1G97_Power_NOT U?
-U 1 1 5E4A29B8
-P 2980 2870
-AR Path="/5CB7A8BC/5E4A29B8" Ref="U?"  Part="1"
-AR Path="/5CB7A8C3/5E4A29B8" Ref="U?"  Part="1"
-AR Path="/5EAE4ADE/5E4A29B8" Ref="U?"  Part="1"
-F 0 "U?" H 3040 3020 50  0000 L CNN
-F 1 "74LVC1G97" H 3040 2720 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-363_SC-70-6" H 3030 2870 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g97.pdf" H 3030 2870 50  0001 C CNN
-F 4 "296-15582-1-ND" H 2980 2870 50  0001 C CNN "Digi-Key PN"
-	1    2980 2870
-	1    0    0    -1
-$EndComp
 $EndSCHEMATC

Commit message: few sch additions
Parts:
- removed C?: 4.7uF, Capacitors_SMD:C_0805, symbol Custom_Library:C_Custom
- added C?: 10uF, Capacitors_SMD:C_0402, symbol Custom_Library:C_Custom
- added U? (x5): 74LVC1G06, TO_SOT_Packages_SMD:SOT-353_SC-70-5, symbol Custom_Library:74LVC1G06_Power
Changed lines of the file:
@@
-$Comp
-L Custom_Library:C_Custom C?
-U 1 1 5E1765D3
-P 2570 2180
-AR Path="/5A0BC776/5E1765D3" Ref="C?"  Part="1"
-AR Path="/5CB7A8C3/5E1765D3" Ref="C?"  Part="1"
-AR Path="/5EAE4ADE/5E1765D3" Ref="C?"  Part="1"
-F 0 "C?" H 2595 2280 50  0000 L CNN
-F 1 "4.7uF" H 2595 2080 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0805" H 2608 2030 50  0001 C CNN
-F 3 "" H 2595 2280 50  0001 C CNN
-F 4 "0805" H 2420 2280 50  0000 R CNN "display_footprint"
-F 5 "16V" H 2420 2180 50  0000 R CNN "Voltage"
-F 6 "X7R" H 2420 2080 50  0000 R CNN "Dielectric"
-F 7 "1276-2970-1-ND" H -3330 -2380 50  0001 C CNN "Digi-Key PN"
-	1    2570 2180
-	1    0    0    -1
-$EndComp
 $Comp
 L Custom_Library:C_Custom C?
@@
 Wire Wire Line
 	2570 1950 2980 1950
+$Comp
+L Custom_Library:74LVC1G06_Power U?
+U 1 1 5EBA890C
+P 2980 2870
+F 0 "U?" H 3080 3020 50  0000 L CNN
+F 1 "74LVC1G06" H 3080 2770 50  0000 L CNN
+F 2 "TO_SOT_Packages_SMD:SOT-353_SC-70-5" H 2980 2920 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g06.pdf" H 2980 2870 50  0001 C CNN
+F 4 "296-8484-1-ND" H 2980 2870 50  0001 C CNN "Digi-Key PN"
+	1    2980 2870
+	1    0    0    -1
+$EndComp
+$Comp
+L Custom_Library:74LVC1G06_Power U?
+U 1 1 5EBAD160
+P 4980 2870
+F 0 "U?" H 5080 3020 50  0000 L CNN
+F 1 "74LVC1G06" H 5080 2770 50  0000 L CNN
+F 2 "TO_SOT_Packages_SMD:SOT-353_SC-70-5" H 4980 2920 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g06.pdf" H 4980 2870 50  0001 C CNN
+F 4 "296-8484-1-ND" H 4980 2870 50  0001 C CNN "Digi-Key PN"
+	1    4980 2870
+	1    0    0    -1
+$EndComp
+$Comp
+L Custom_Library:74LVC1G06_Power U?
+U 1 1 5EBADD05
+P 6980 2870
+F 0 "U?" H 7080 3020 50  0000 L CNN
+F 1 "74LVC1G06" H 7080 2770 50  0000 L CNN
+F 2 "TO_SOT_Packages_SMD:SOT-353_SC-70-5" H 6980 2920 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g06.pdf" H 6980 2870 50  0001 C CNN
+F 4 "296-8484-1-ND" H 6980 2870 50  0001 C CNN "Digi-Key PN"
+	1    6980 2870
+	1    0    0    -1
+$EndComp
+$Comp
+L Custom_Library:74LVC1G06_Power U?
+U 1 1 5EBAE6FA
+P 8980 2870
+F 0 "U?" H 9080 3020 50  0000 L CNN
+F 1 "74LVC1G06" H 9080 2770 50  0000 L CNN
+F 2 "TO_SOT_Packages_SMD:SOT-353_SC-70-5" H 8980 2920 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g06.pdf" H 8980 2870 50  0001 C CNN
+F 4 "296-8484-1-ND" H 8980 2870 50  0001 C CNN "Digi-Key PN"
+	1    8980 2870
+	1    0    0    -1
+$EndComp
+$Comp
+L Custom_Library:74LVC1G06_Power U?
+U 1 1 5EBAEFAB
+P 2980 4370
+F 0 "U?" H 3080 4520 50  0000 L CNN
+F 1 "74LVC1G06" H 3080 4270 50  0000 L CNN
+F 2 "TO_SOT_Packages_SMD:SOT-353_SC-70-5" H 2980 4420 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/sn74lvc1g06.pdf" H 2980 4370 50  0001 C CNN
+F 4 "296-8484-1-ND" H 2980 4370 50  0001 C CNN "Digi-Key PN"
+	1    2980 4370
+	1    0    0    -1
+$EndComp
+$Comp
+L Custom_Library:C_Custom C?
+U 1 1 5EBBADED
+P 2570 2180
+AR Path="/5CB7718D/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5E0DC082/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5E0F9110/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5A557C58/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5CB25152/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5E697934/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5EAE2F02/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5EAE3021/5EBBADED" Ref="C?"  Part="1"
+AR Path="/5EAE4ADE/5EBBADED" Ref="C?"  Part="1"
+F 0 "C?" H 2595 2280 50  0000 L CNN
+F 1 "10uF" H 2595 2080 50  0000 L CNN
+F 2 "Capacitors_SMD:C_0402" H 2608 2030 50  0001 C CNN
+F 3 "" H 2595 2280 50  0001 C CNN
+F 4 "0402" H 2420 2280 50  0000 R CNN "display_footprint"
+F 5 "6.3V" H 2420 2180 50  0000 R CNN "Voltage"
+F 6 "X5R" H 2420 2080 50  0000 R CNN "Dielectric"
+F 7 "490-13211-1-ND" H 2570 2180 50  0001 C CNN "Digi-Key PN"
+	1    2570 2180
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC

Commit message: Added more stuff to sch
Parts:
- removed U?: TPS71533, Package_TO_SOT_SMD:SOT-353_SC-70-5, symbol Regulator_Linear:TPS71533__SC70
- added U?: TPS71530, Package_TO_SOT_SMD:SOT-353_SC-70-5, symbol Regulator_Linear:TPS71530__SC70
- C? (x5): footprint Capacitors_SMD:C_0603 -> Capacitors_SMD:C_0402; Digi-Key PN 311-1344-1-ND -> 490-10701-1-ND; display_footprint 0603 -> (none)
- R? (x5): footprint Resistors_SMD:R_0603 -> Resistors_SMD:R_0402; Digi-Key PN RMCF0603FT1K00CT-ND -> (none); Wattage 1/10W -> 1/16W; display_footprint 0603 -> 0402
Connections:
- net +12V: now also U?.4 (IN)
- net GND: now also U?.2 (GND)
- net at C?.1, R?.1, U?.5 (VCC): now also U?.5 (OUT)
Changed lines of the file:
@@
 $Descr A 11000 8500
 encoding utf-8
-Sheet 18 19
-Title ""
+Sheet 18 20
+Title "Pulse Oximeter"
 Date ""
-Rev ""
-Comp ""
+Rev "A"
+Comp "Drew Maatman"
 Comment1 ""
 Comment2 ""
@@
 F 0 "C?" H 1485 2280 50  0000 L CNN
 F 1 "0.1uF" H 1485 2080 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0603" H 1498 2030 50  0001 C CNN
+F 2 "Capacitors_SMD:C_0402" H 1498 2030 50  0001 C CNN
 F 3 "" H 1485 2280 50  0001 C CNN
-F 4 "311-1344-1-ND" H 1885 2680 60  0001 C CNN "Digi-Key PN"
-F 5 "0603" H 1310 2280 50  0000 R CNN "display_footprint"
+F 4 "490-10701-1-ND" H 1885 2680 60  0001 C CNN "Digi-Key PN"
+F 5 "" H 1310 2280 50  0000 R CNN "display_footprint"
 F 6 "50V" H 1310 2180 50  0000 R CNN "Voltage"
 F 7 "X7R" H 1310 2080 50  0000 R CNN "Dielectric"
@@
 F 0 "R?" H 3490 2300 50  0000 R CNN
 F 1 "1k" V 3550 2300 50  0000 C CNN
-F 2 "Resistors_SMD:R_0603" H 3550 2300 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" H 3550 2300 50  0001 C CNN
 F 3 "" H 3550 2300 50  0001 C CNN
-F 4 "0603" H 3620 2380 50  0000 L CNN "display_footprint"
+F 4 "0402" H 3620 2380 50  0000 L CNN "display_footprint"
 F 5 "1%" H 3620 2300 50  0000 L CNN "Tolerance"
-F 6 "1/10W" H 3620 2230 50  0000 L CNN "Wattage"
-F 7 "RMCF0603FT1K00CT-ND" H 3850 2700 60  0001 C CNN "Digi-Key PN"
+F 6 "1/16W" H 3620 2230 50  0000 L CNN "Wattage"
+F 7 "" H 3850 2700 60  0001 C CNN "Digi-Key PN"
 	1    3550 2300
 	-1   0    0    -1
@@
 F 0 "C?" H 4895 2280 50  0000 L CNN
 F 1 "0.1uF" H 4895 2080 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0603" H 4908 2030 50  0001 C CNN
+F 2 "Capacitors_SMD:C_0402" H 4908 2030 50  0001 C CNN
 F 3 "" H 4895 2280 50  0001 C CNN
-F 4 "311-1344-1-ND" H 5295 2680 60  0001 C CNN "Digi-Key PN"
-F 5 "0603" H 4720 2280 50  0000 R CNN "display_footprint"
+F 4 "490-10701-1-ND" H 5295 2680 60  0001 C CNN "Digi-Key PN"
+F 5 "" H 4720 2280 50  0000 R CNN "display_footprint"
 F 6 "50V" H 4720 2180 50  0000 R CNN "Voltage"
 F 7 "X7R" H 4720 2080 50  0000 R CNN "Dielectric"
@@
 F 0 "R?" H 5490 2300 50  0000 R CNN
 F 1 "1k" V 5550 2300 50  0000 C CNN
-F 2 "Resistors_SMD:R_0603" H 5550 2300 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" H 5550 2300 50  0001 C CNN
 F 3 "" H 5550 2300 50  0001 C CNN
-F 4 "0603" H 5620 2380 50  0000 L CNN "display_footprint"
+F 4 "0402" H 5620 2380 50  0000 L CNN "display_footprint"
 F 5 "1%" H 5620 2300 50  0000 L CNN "Tolerance"
-F 6 "1/10W" H 5620 2230 50  0000 L CNN "Wattage"
-F 7 "RMCF0603FT1K00CT-ND" H 5850 2700 60  0001 C CNN "Digi-Key PN"
+F 6 "1/16W" H 5620 2230 50  0000 L CNN "Wattage"
+F 7 "" H 5850 2700 60  0001 C CNN "Digi-Key PN"
 	1    5550 2300
 	-1   0    0    -1
@@
 F 0 "C?" H 6895 2280 50  0000 L CNN
 F 1 "0.1uF" H 6895 2080 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0603" H 6908 2030 50  0001 C CNN
+F 2 "Capacitors_SMD:C_0402" H 6908 2030 50  0001 C CNN
 F 3 "" H 6895 2280 50  0001 C CNN
-F 4 "311-1344-1-ND" H 7295 2680 60  0001 C CNN "Digi-Key PN"
-F 5 "0603" H 6720 2280 50  0000 R CNN "display_footprint"
+F 4 "490-10701-1-ND" H 7295 2680 60  0001 C CNN "Digi-Key PN"
+F 5 "" H 6720 2280 50  0000 R CNN "display_footprint"
 F 6 "50V" H 6720 2180 50  0000 R CNN "Voltage"
 F 7 "X7R" H 6720 2080 50  0000 R CNN "Dielectric"
@@
 F 0 "R?" H 7490 2300 50  0000 R CNN
 F 1 "1k" V 7550 2300 50  0000 C CNN
-F 2 "Resistors_SMD:R_0603" H 7550 2300 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" H 7550 2300 50  0001 C CNN
 F 3 "" H 7550 2300 50  0001 C CNN
-F 4 "0603" H 7620 2380 50  0000 L CNN "display_footprint"
+F 4 "0402" H 7620 2380 50  0000 L CNN "display_footprint"
 F 5 "1%" H 7620 2300 50  0000 L CNN "Tolerance"
-F 6 "1/10W" H 7620 2230 50  0000 L CNN "Wattage"
-F 7 "RMCF0603FT1K00CT-ND" H 7850 2700 60  0001 C CNN "Digi-Key PN"
+F 6 "1/16W" H 7620 2230 50  0000 L CNN "Wattage"
+F 7 "" H 7850 2700 60  0001 C CNN "Digi-Key PN"
 	1    7550 2300
 	-1   0    0    -1
@@
 F 0 "C?" H 8895 2280 50  0000 L CNN
 F 1 "0.1uF" H 8895 2080 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0603" H 8908 2030 50  0001 C CNN
+F 2 "Capacitors_SMD:C_0402" H 8908 2030 50  0001 C CNN
 F 3 "" H 8895 2280 50  0001 C CNN
-F 4 "311-1344-1-ND" H 9295 2680 60  0001 C CNN "Digi-Key PN"
-F 5 "0603" H 8720 2280 50  0000 R CNN "display_footprint"
+F 4 "490-10701-1-ND" H 9295 2680 60  0001 C CNN "Digi-Key PN"
+F 5 "" H 8720 2280 50  0000 R CNN "display_footprint"
 F 6 "50V" H 8720 2180 50  0000 R CNN "Voltage"
 F 7 "X7R" H 8720 2080 50  0000 R CNN "Dielectric"
@@
 F 0 "R?" H 9490 2300 50  0000 R CNN
 F 1 "1k" V 9550 2300 50  0000 C CNN
-F 2 "Resistors_SMD:R_0603" H 9550 2300 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" H 9550 2300 50  0001 C CNN
 F 3 "" H 9550 2300 50  0001 C CNN
-F 4 "0603" H 9620 2380 50  0000 L CNN "display_footprint"
+F 4 "0402" H 9620 2380 50  0000 L CNN "display_footprint"
 F 5 "1%" H 9620 2300 50  0000 L CNN "Tolerance"
-F 6 "1/10W" H 9620 2230 50  0000 L CNN "Wattage"
-F 7 "RMCF0603FT1K00CT-ND" H 9850 2700 60  0001 C CNN "Digi-Key PN"
+F 6 "1/16W" H 9620 2230 50  0000 L CNN "Wattage"
+F 7 "" H 9850 2700 60  0001 C CNN "Digi-Key PN"
 	1    9550 2300
 	-1   0    0    -1
@@
 F 0 "C?" H 2895 3780 50  0000 L CNN
 F 1 "0.1uF" H 2895 3580 50  0000 L CNN
-F 2 "Capacitors_SMD:C_0603" H 2908 3530 50  0001 C CNN
+F 2 "Capacitors_SMD:C_0402" H 2908 3530 50  0001 C CNN
 F 3 "" H 2895 3780 50  0001 C CNN
-F 4 "311-1344-1-ND" H 3295 4180 60  0001 C CNN "Digi-Key PN"
-F 5 "0603" H 2720 3780 50  0000 R CNN "display_footprint"
+F 4 "490-10701-1-ND" H 3295 4180 60  0001 C CNN "Digi-Key PN"
+F 5 "" H 2720 3780 50  0000 R CNN "display_footprint"
 F 6 "50V" H 2720 3680 50  0000 R CNN "Voltage"
 F 7 "X7R" H 2720 3580 50  0000 R CNN "Dielectric"
@@
 F 0 "R?" H 3490 3800 50  0000 R CNN
 F 1 "1k" V 3550 3800 50  0000 C CNN
-F 2 "Resistors_SMD:R_0603" H 3550 3800 50  0001 C CNN
+F 2 "Resistors_SMD:R_0402" H 3550 3800 50  0001 C CNN
 F 3 "" H 3550 3800 50  0001 C CNN
-F 4 "0603" H 3620 3880 50  0000 L CNN "display_footprint"
+F 4 "0402" H 3620 3880 50  0000 L CNN "display_footprint"
 F 5 "1%" H 3620 3800 50  0000 L CNN "Tolerance"
-F 6 "1/10W" H 3620 3730 50  0000 L CNN "Wattage"
-F 7 "RMCF0603FT1K00CT-ND" H 3850 4200 60  0001 C CNN "Digi-Key PN"
+F 6 "1/16W" H 3620 3730 50  0000 L CNN "Wattage"
+F 7 "" H 3850 4200 60  0001 C CNN "Digi-Key PN"
 	1    3550 3800
 	-1   0    0    -1
@@
 Text GLabel 2680 4370 0    50   Input ~ 0
 POS5_USB_PGOOD
-$Comp
-L Regulator_Linear:TPS71533__SC70 U?
-U 1 1 5E4D26A0
-P 1990 1950
-F 0 "U?" H 1840 2075 50  0000 C CNN
-F 1 "TPS71533" H 1990 2075 50  0000 L CNN
-F 2 "Package_TO_SOT_SMD:SOT-353_SC-70-5" H 1990 2175 50  0001 C CNN
-F 3 "http://www.ti.com/lit/ds/symlink/tps715.pdf" H 1690 2750 50  0001 C CNN
-F 4 "296-12008-1-ND" H 1990 1950 50  0001 C CNN "Digi-Key PN"
-	1    1990 1950
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	2290 1950 2570 1950
@@
 	1    0    0    -1
 $EndComp
+$Comp
+L Regulator_Linear:TPS71530__SC70 U?
+U 1 1 5EC00B51
+P 1990 1950
+F 0 "U?" H 1840 2075 50  0000 C CNN
+F 1 "TPS71530" H 1990 2075 50  0000 L CNN
+F 2 "Package_TO_SOT_SMD:SOT-353_SC-70-5" H 1990 2175 50  0001 C CNN
+F 3 "http://www.ti.com/lit/ds/symlink/tps715.pdf" H 1690 2750 50  0001 C CNN
+	1    1990 1950
+	1    0    0    -1
+$EndComp

Commit message: Added digikey pn's, footprints
Parts:
- D1801, D1802, D1803, D1804, D1805: renamed from D?; footprint LEDs:LED_0603 -> LEDs:LED_0402; Digi-Key PN 160-1446-1-ND -> 1497-1219-1-ND
- R1801, R1802, R1803, R1804, R1805: renamed from R?; Digi-Key PN (none) -> 541-1.00KLCT-ND
- U1801: renamed from U?; Digi-Key PN (none) -> 296-15045-1-ND
- gave numbers to parts that had none: 11
